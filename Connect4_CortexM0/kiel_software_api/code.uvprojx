# Keil uVision project code.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: code
  AfterMake: fromelf --bin code.axf -o code.bin
  AfterMake: fromelf -cvf code.axf --vhx --32x1 -o code.hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\Application;.\Core;.\Device
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Device
    ./Device/: retarget.c edk_api.c edk_api.h EDK_CM0.h edk_driver.h
    ../: wells version edk_driver.c cm0dsasm_multiple_inputs_gpio.s
  group Application
    ../: main_uart_with_pause_multiple_switches.c
  group Core
    ./Core/: core_cm0.h core_cmFunc.h core_cmInstr.h
software components: CMSIS:CORE 5.2.0
